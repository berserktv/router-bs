# подменяю конфигурационные файлы и стартовые скрипты см. каталог files
# конфигурационный файл dhcpd.conf
# и файл с описанием сетевого интерфейса, на котором dhcp работает, файл default-server
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
