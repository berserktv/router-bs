# дополнительный параметры конфигурации описываются в router-extra.cfg
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://router-extra.cfg"
