FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

###hostname = "orange-pi-zero"
