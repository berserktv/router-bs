IMAGE_INSTALL += " \
                        swupdate \
                        swupdate-www \
                 "
